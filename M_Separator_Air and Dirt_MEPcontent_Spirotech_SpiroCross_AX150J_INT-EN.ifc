Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: f3a51646-a1de-4539-a2f9-f600db158adc, NumberOfSaves: 173]
File name: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCross_AX150J_INT-EN.ifc
Time: 2025-08-05T18:33:16+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENG) - IFC 23.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuildingStorey: Level:Floor Level (3)
Pset_BuildingStoreyCommon - Reference: Floor Level
Other - Category: Levels; Family: Level; Family and Type: Level: Floor Level; Type: Floor Level; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent : standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Floor Level
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
F00 | F00 | 0
F01 | F01 | 3300
F02 | F02 | 6600

# IfcDistributionPort (4)
Description: Flow; FlowDirection: SOURCEANDSINK; PredefinedType: PIPE
Name
Port_2132093_1
Port_2132093_2
Port_2132093_3
Port_2132093_4

# IfcValve: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCross_AX100J-150J_INT-EN:AX150J, M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCross_AX100J-150J_INT-EN:AX150J:2132093
In: F00
Type - Material: Color RGB 040-040-040, Color RGB 168-128-048
Type - Other - Category: Pipe Accessories; Connection Diameter: 38.1 mm; Family Name: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCross_AX100J-150J_INT-EN; h: 135 mm; h1: 144 mm; h2: 183 mm; Nominal Diameter: 38.1 mm; Outer Diameter: 48.3 mm; Radius Safe: 24.5 mm
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - d: 38.1 mm; H: 462 mm; L: 236 mm; Use Nominal Diameter: yes
Type - Identity Data - Article Description: Low-los Header with Deaerator & dirt separator - Brass 1 1/2"; Article Type: AX150J; Base Family Version: 25.09; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Low-los Header with Deaerator & dirt separator - Brass 1 1/2"; EMCS Version: 4.0; ETIM Article Class: EC010260; Family Version: 22.11; GLN: 8717811000007; GTIN: 8717811055809; Manufacturer: Spirotech; Manufacturer Art. No.: AX150J; Manufacturer URL: https://www.spirotech.com/8717811055809; MEPcontent Class: SEPARATOR_AIR_AND_DIRT; Model: AX150J; OmniClass Number: 23.70.50.14.31; OmniClass Title: Liquid Waste Separators; Product Line: Spirotech; Revit Version: 2023; Type Name: AX150J; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Black: Color RGB 040-040-040; Dark Yellow: Color RGB 168-128-048
Type - Mechanical - Capacity: 0; Flow-through Capacity: 0 m3/s; Maximum Flow Rate: 0.00139 m3/s; Pressure Stage: 0; Volume: 0.0013 m3; Weight: 6.7 kg
Type - Mechanical - Flow - Pressure Drop: 0 Pa
Type - Pset_ManufacturerTypeInformation - Manufacturer: Spirotech
Pset_EnvironmentalImpactIndicators - Reference: AX150J; sets with these values: 2
Other - Bottom Clearance Safe: 100 mm; Family: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCross_AX100J-150J_INT-EN; Family and Type: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCross_AX100J-150J_INT-EN: AX150J; Top Clearance Safe: 50 mm; Type: AX150J; Type Id: 2132076
Constraints - Actual Offset: 10 mm; Elevation from Level: 0 mm; Negative Offset: 10 mm
Dimensions - Area: 0.215664 m2; Maximum Size: 38.1 mm; Minimum Size: 38.1 mm; Volume: 0.0024153 m3
Graphics - Annotation Offset RL: 0 mm
Identity Data - Mark: 11
Mechanical - System Classification: Undefined
Mechanical - Flow - Flow 1: 0 m3/s; Flow 2: 0 m3/s; Flow 3: 0 m3/s; Flow 4: 0 m3/s
Phasing - Phase Created: 3. New Construction
Visibility - Bottom Clearance: 100 mm; Service Space: no; Top Clearance: 50 mm
Insulation - Insulation Thickness: 0 mm
